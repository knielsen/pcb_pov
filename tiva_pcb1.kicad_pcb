# Repository knielsen/pcb_pov

## KiCad design tiva_pcb1.kicad_pcb

Parts:
B1: SWITCH_4PIN
C1, C2, C3, C4, C5, C9, C10, C17: 100n
C6: 10u
C7, C8: 10p
C11, C14, C20: 1u
C12, C13: 2.2u
C15: 100u
C16, C18, C21: 10n
C19: 220n
D1: SML-211UTT86
D2: SML-211YTT86
D3: BAV99LT3G
K1: CONN_3
L1: 30@100MHz
P1, P2, P3: CONN_5X2
P4: MICRO-SD
P5: CONN_2
P6: CONN_3
P7: CONN_4X2
P8: CONN_9
P9: CONN_3X2
R1, R3, R4: 10k
R2, R18, R19: 0
R5, R11, R12, R13, R14, R15, R16, R17: 47k
R6: 100
R7, R8: 1k
R9, R10: 0R22
U1: TM4C1232XXPM
U2: LP2985LV
U3: KNUSB
U4: L6234
X1: NX5032GA-16MHz

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C13.1, P4.4 (VDD), P7.2, P8.9, R1.1, R3.2, R4.1, R5.1, R7.1, R11.2, R12.2, R13.2, R17.2, U1.2 (VDDA), U1.11 (VDD), U1.26 (VDD), U1.42 (VDD), U1.54 (VDD), U2.5 (VOUT)
+12V: C15.1, C17.1, D3.1 (Anode), P6.3, P9.3, U4.9 (VS), U4.12 (VS)
/blank1: P1.8, R11.1, U1.14 (PC6)
/blank2: P2.8, R12.1, U1.6 (PE3)
/blank3: P3.8, R13.1, U1.60 (PE5)
/bypass: C21.1, U2.4 (BYPASS)
/gsclk1: P1.4, U1.16 (PC4)
/gsclk2: P2.4, U1.5 (PF4)
/gsclk3: P3.4, U1.57 (PB5)
/hall1: P1.10, U1.15 (PC5)
/hall2: P2.10, U1.10 (PD7)
/hall3: P3.10, U1.53 (PD6)
/m_en1: R16.2, U1.34 (PG3), U4.8 (EN1)
/m_en2: R15.2, U1.33 (PG4), U4.3 (EN2)
/m_en3: R14.2, U1.32 (PG5), U4.13 (EN3)
/m_in1: U1.37 (PG0), U4.7 (IN1)
/m_in2: U1.36 (PG1), U4.4 (IN2)
/m_in3: U1.35 (PG2), U4.14 (IN3)
/m_out1: K1.1, U4.6 (OUT1)
/m_out2: K1.2 (PM), U4.5 (OUT2)
/m_out3: K1.3, U4.15 (OUT3)
/m_sense1: R18.2, U1.8 (PE1)
/m_sense1_raw: R9.1, R18.1, U4.2 (SENSE1)
/m_sense2: R19.2, U1.9 (PE0)
/m_sense2_raw: R10.1, R19.1, U4.19 (SENSE2)
/mode1: P1.5, U1.23 (PA6)
/mode2: P2.5, U1.13 (PC7)
/mode3: P3.5, U1.62 (PD1)
/nrf_ce: P7.3, U1.48 (PB3/I2C0SDA)
/nrf_cs: P7.4, R17.1, U1.31 (PF3)
/nrf_irq: P7.8, U1.45 (PB0)
/reset: C16.2, P8.1, R1.2, R6.2, U1.38 (RESET)
/sclk1: P1.6, U1.19 (PA2/SSI0Clk)
/sclk2: P2.6, U1.58 (PB4)
/sclk3: P3.6, U1.61 (PD0)
/sd_cd: P4.10 (CD_PWR), R2.2
/sd_cd2: R2.1, U1.47 (PB2/I2C0SCL)
/sd_cs: P4.2 (CS), R5.2, U1.46 (PB1)
/sin1: P1.3, U1.22 (PA5/SSI0Tx)
/sin2: P2.3, U1.4 (PB7)
/sin3: P3.3, U1.64 (PD3)
/sout1: P1.9, U1.21 (PA4/SSI0Rx)
/sout2: P2.9, U1.1 (PB6)
/sout3: P3.9, U1.63 (PD2)
/ssi1clk: P4.5 (SCLK), P7.5, U1.30 (PF2)
/ssi1rx: P4.7 (DO), P7.7, U1.28 (PF0)
/ssi1tx: P4.3 (DI), P7.6, U1.29 (PF1)
/tck: P8.7, R3.1, U1.52 (PC0/TCK)
/tdi: P8.4, U1.50 (PC2/TDI)
/tdo: P8.5, U1.49 (PC3/TDO)
/tms: P8.6, R4.2, U1.51 (PC1/TMS)
/u0rx: P8.2, U1.17 (PA0/U0Rx)
/u0tx: P8.3, U1.18 (PA1/U0Tx)
/usb5v: P9.5, U3.1 (VBUS)
/usb_dm: U1.43 (PD4/USB0DM), U3.2 (D-)
/usb_dp: U1.44 (PD5/USB0DP), U3.3 (D+)
/user_led: R8.1, U1.24 (PA7)
/vbat: P1.1, P2.1, P3.1, P5.1, P9.1
/vboot: C19.1, D3.2 (cathode), U4.18 (VBOOT)
/vcp: C18.1, U4.17 (VCP)
/vdcc: C9.1, C10.1, C11.1, C12.1, U1.25 (VDCC), U1.56 (VDCC)
/vref: C20.1, U4.16 (VREF)
/xlat1: P1.7, U1.20 (PA3/SSI0Fss)
/xlat2: P2.7, U1.7 (PE2)
/xlat3: P3.7, U1.59 (PE4)
GND: B1.3, B1.4, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C19.2, C20.2, C21.2, D1.2 (K), D2.2 (K), L1.2, P1.2, P2.2, P3.2, P4.6 (VSS), P4.9 (CD_GND), P5.2 (PM), P6.2 (PM), P7.1, P8.8, R9.2, R10.2, R14.1, R15.1, R16.1, U1.3 (GNDA), U1.12 (GND), U1.27 (GND), U1.39 (GND), U1.55 (GND), U2.2 (GND), U3.5 (GND), U4.1 (GND), U4.10 (GND), U4.11 (GND), U4.20 (GND), U4.21 (GND_PAD)
unnamed: B1.1, B1.2, R6.1
unnamed: C7.1, U1.41 (OSC1), X1.1
unnamed: C8.1, U1.40 (OSC0), X1.2
unnamed: C18.2, D3.3 (AK)
unnamed: D1.1 (A), R7.2
unnamed: D2.1 (A), R8.2
unnamed: L1.1, U3.6 (SHIELD)
VCC: C14.1, P9.2, P9.4, P9.6, U2.1 (VIN), U2.3 (ON/OFF)

Notes on the sheet:
Place C12 as close as possible to pin 56
Jumper 1-2 selects battery power Jumper 3-4 selects external 12V jack power Jumper 5-6 selects USB power
0 ohm resistors, connecting TM4C analog input to motor R_sense
R3 and R4 need not be fitted

Board: 4 copper layers, 50.0 x 50.0 mm, 61 parts (21 on the bottom side), 74 nets.

Other parts of the board:
1PIN_6mm: P***; 1PIN_6mm

## Commit log

2013-11-15 Initial commit of POV control board, not yet complete.
    Schematics is mostly done, components are assigned and placed.
    Critical routing (power+usb) done.
    Commit now before experimenting with freerouting.net autorouting.
2013-11-15 Tweak a couple of things, in preparation for another autoroute attempt:
    - Fix position of the connectors around the edge of the board.
    - Proper ground plane zone fill.
    - Move USB data lines a bit to make more routing space.
    - Re-route the +3.3V along the top of the board to make more space for
    routing below where there are more signals.
2013-12-07 First complete version.
    Everything routed, DRC passes. Silk screen done, gerbers checked briefly.
2013-12-08 Final gerbers for rev1 manufature
